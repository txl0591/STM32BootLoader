# IAR project STM32BootLoader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\System\Include; ..\System\Cpu\stm32f10x\core; ..\System\Driver\; ..\System\Driver\Peripheral\dma; ..\System\Driver\Peripheral\pwr; ..\System\Driver\Peripheral\exti; ..\System\Driver\Peripheral\flash; ..\System\Driver\Peripheral\gpio; ..\System\Driver\Peripheral\misc; ..\System\Driver\Peripheral\rcc; ..\System\Driver\Peripheral\usart; ..\System\Driver\Peripheral\usb; ..\System\Driver\HAL\Serial; ..\System\Driver\HAL\Usb; ..\System\Driver\HAL\Flash; ..\System\Driver\HAL\Key
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32BootLoader.bin
  ILINK.IlinkOutputFile: STM32BootLoader.out
  ILINK.IlinkIcfFile: D:\code\workspace\STM32\STM32_BootLoader\System\Cpu\stm32f10x\linker\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application/Main
    ../Application/Main/: appmain.c
  group System/Cpu/stm32f10x/core
    ../System/Cpu/stm32f10x/core/: core_cm3.c core_cm3.h core_cmFunc.h core_cmInstr.h system_stm32f10x.c system_stm32f10x.h
  group System/Cpu/stm32f10x/loader
    ../System/Cpu/stm32f10x/loader/: startup_stm32f10x_hd.s
  group System/Driver
    ../System/Driver/: hw_config.c hw_config.h hw_define.h
  group System/Driver/Hal/flash
    ../System/Driver/Hal/flash/: hw_flash.c hw_flash.h
  group System/Driver/Hal/key
    ../System/Driver/Hal/key/: key.c key.h
  group System/Driver/Hal/serial
    ../System/Driver/Hal/serial/: hw_serial.c hw_serial.h
  group System/Driver/Hal/usbduf
    ../System/Driver/Hal/usb/: usb_desc.c usb_desc.h usb_endp.c usb_istr.c usb_istr.h usb_prop.c usb_prop.h usb_pwr.c usb_pwr.h
  group System/Driver/Peripheral/dma
    ../System/Driver/Peripheral/dma/: stm32f10x_dma.c stm32f10x_dma.h
  group System/Driver/Peripheral/exti
    ../System/Driver/Peripheral/exti/: stm32f10x_exti.c stm32f10x_exti.h
  group System/Driver/Peripheral/flash
    ../System/Driver/Peripheral/flash/: stm32f10x_flash.c stm32f10x_flash.h
  group System/Driver/Peripheral/gpio
    ../System/Driver/Peripheral/gpio/: stm32f10x_gpio.c stm32f10x_gpio.h
  group System/Driver/Peripheral/misc
    ../System/Driver/Peripheral/misc/: misc.c misc.h
  group System/Driver/Peripheral/pwr
    ../System/Driver/Peripheral/pwr/: stm32f10x_pwr.c stm32f10x_pwr.h
  group System/Driver/Peripheral/rcc
    ../System/Driver/Peripheral/rcc/: stm32f10x_rcc.c stm32f10x_rcc.h
  group System/Driver/Peripheral/usart
    ../System/Driver/Peripheral/usart/: stm32f10x_usart.c stm32f10x_usart.h
  group System/Driver/Peripheral/usb
    ../System/Driver/Peripheral/usb/: usb_conf.h usb_core.c usb_core.h usb_def.h usb_init.c usb_init.h usb_int.c usb_int.h usb_lib.h usb_mem.c usb_mem.h usb_regs.c usb_regs.h usb_sil.c usb_sil.h usb_type.h
  group System/Include
    ../System/Include/: appmain.h stm32f10x.h stm32f10x_conf.h
  group System/Init
    ../System/Init/: main.c stm32f10x_it.c stm32f10x_it.h
